## meta-tannhauser/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/recipes-*/*/*.bb"
LAYERDEPENDS_tannhauser = "core"
LAYERSERIES_COMPAT_tannhauser = "kirkstone"
```
